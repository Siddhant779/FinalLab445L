# Keil uVision project Tpod.uvprojx, settings and files
target Target 1 (6150000::V6.15::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Tpod
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: rvmdk PART_LM4F120H5QR
  c include: ./;../
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group inc
    ../inc/: DAC.c LaunchPad.c PLL.c startup.s Timer0A.c UART.c Unified_Port_Init.c Timer2A.c Timer1A.c Timer4A.c Timer3A.c esp8266_base.c tm4c123gh6pm.h UART5.c Timer5A.c
  group lib
    ../lib/SD/: eDisk.c eFile.c ff.c SD.c
  group src
    ./: lab.c Switch.c Music.c ILI9341.c Display.c Messages.c FSM.c
